# Repository riera90/e-printed-exam

## KiCad design hardware/eprintedexam.kicad_pcb

Parts:
BT1: Battery_Cell; BatteryHolder_MPD_BH-18650-PC2
C1, C2, C6, C7: 100n; C_1206_3216Metric
C3: 100u; CP_Radial_D6.3mm_P2.50mm
C4: 220u; CP_Radial_D6.3mm_P2.50mm
C5: 47u; CP_Radial_D6.3mm_P2.50mm
D1, D2: 2N7001; D_DO-35_SOD27_P10.16mm_Horizontal
H1, H2, H3, H4: MountingHole; MountingHole_3mm
J1: Conn_01x08; PinHeader_1x08_P2.54mm_Vertical
J2: Conn_01x04; PinSocket_1x04_P2.54mm_Vertical
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11: 2N7002; SOT-23
R1, R2: 5k; R_1206_3216Metric
R3, R4, R10: 33k; R_1206_3216Metric
R5, R7, R14, R15, R16, R17, R18, R19, R20, R21: 10k; R_1206_3216Metric
R6, R12: 0; R_1206_3216Metric
R8: 330; R_1206_3216Metric
R9: 3.3k; R_1206_3216Metric
R11: 680k; R_1206_3216Metric
R13: 18k; R_1206_3216Metric
SW1, SW2, SW3, SW4: SW_Push; SW_SPST_TL3342
TP1, TP2, TP3, TP4, TP5, TP6: TestPoint; TestPoint_Pad_D1.5mm
U1: AP1117-33; SOT-223-3_TabPin2
U2: ESP-12F; ESP-12E

Connections:
GND: BT1.2 (-), C1.2, C2.2, C3.2, C4.2, C7.1, J1.2, J2.2, Q2.2 (S), Q3.2 (S), Q4.2 (S), Q5.2 (S), Q6.2 (S), Q7.2 (S), Q8.2 (S), Q9.2 (S), Q10.2 (S), Q11.2 (S), R4.2, R6.1, R6.2, R8.2, R16.1, SW1.1, SW2.1, SW3.1, SW4.1, U2.15 (GND); also elsewhere on the board
unnamed: BT1.1 (+), D1.1 (K), U1.3 (VI)
unnamed: C3.1, U1.1 (GND)
unnamed: C5.1, D2.2 (A), Q4.3 (D), Q6.1 (G), R5.2
unnamed: C6.1, Q5.3 (D), R11.2
unnamed: C6.2, Q4.1 (G), R8.1
unnamed: J1.3, R12.1
unnamed: J2.3, U2.21 (GPIO3/RXD)
unnamed: J2.4, U2.22 (GPIO1/TXD)
unnamed: Q1.2 (S), Q2.3 (D)
unnamed: Q1.3 (D), Q3.1 (G), R3.1
unnamed: Q6.3 (D), Q7.1 (G), R13.2
unnamed: R15.1, U2.3 (EN)
unnamed: R17.1, U2.17 (GPIO2)
VCC: C4.1, C7.2, D1.2 (A), D2.1 (K), J1.1, J2.1, R1.1, R2.2, R3.2, R4.1, R5.1, R7.1, R9.1, R10.2, R11.1, R13.1, R14.2, R15.2, R17.2, R18.2, R19.2, R20.2, R21.2, U1.2 (VO), U2.8 (VCC)
nnxt: Q8.3 (D), Q10.1 (G), R18.1
nprv: Q9.3 (D), Q11.1 (G), R19.1
nrst: Q7.3 (D), R14.1, SW4.2, U2.1 (~RST), U2.4 (GPIO16)
nxt: C1.1, Q1.1 (G), Q8.1 (G), R1.2, SW1.2; also elsewhere on the board
nxt+prv: C5.2, Q3.3 (D), Q5.1 (G), R9.2
prv: C2.1, Q2.1 (G), Q9.1 (G), R2.1, SW2.2; also elsewhere on the board
spi-busy,flash: J1.8, R7.2, SW3.2, TP6.1, U2.18 (GPIO0)
spi-clk: J1.4, TP2.1, U2.5 (GPIO14)
spi-cs: J1.5, R16.2, TP3.1, U2.16 (GPIO15)
spi-dc_nxt-in: J1.6, Q10.3 (D), R20.1, TP4.1, U2.19 (GPIO4)
spi-miso_prv-in: Q11.3 (D), R21.1, U2.6 (GPIO12)
spi-mosi: R12.2, TP1.1, U2.7 (GPIO13)
spi-rst: J1.7, R10.1, TP5.1, U2.20 (GPIO5)

Notes on the sheet:
single pulse monostable and filter for reset pulse from nxt+prv signal
logic OR of singals prv and nxt
voltage regulation
flash button
display connector
mounting holes
main esp8266 wiring
test points for display
jumper

Board: 2 copper layers, 103.0 x 98.5 mm, 62 parts (1 on the bottom side), 28 nets.

Other parts of the board:
SW1#2, SW2#2: SW_Push; SW_SPST_TL3342

Their connections:
GND: SW1#2.1, SW2#2.1; also elsewhere on the board
nxt: SW1#2.2; also elsewhere on the board
prv: SW2#2.2; also elsewhere on the board

## KiCad design hardware_simplified/eprintedexam.kicad_pcb

Board: 2 copper layers, 103.0 x 98.5 mm, 55 parts (1 on the bottom side), 23 nets.

Parts:
BT1: Battery_Cell; BatteryHolder_MPD_BH-18650-PC2
C1: 100u; CP_Radial_D8.0mm_P5.00mm
C2: 220u; CP_Radial_D10.0mm_P5.00mm
C3, C4, C5, C7: 100n; C_1206_3216Metric
C6: 47u; CP_Radial_D6.3mm_P2.50mm
D1, D2: 2N7001; D_DO-35_SOD27_P10.16mm_Horizontal
H1, H2, H3, H4: MountingHole; MountingHole_3mm
J1: Conn_01x04; PinSocket_1x04_P2.54mm_Vertical
J2: Conn_01x08; PinHeader_1x08_P2.54mm_Vertical
Q1, Q2, Q3, Q4, Q5, Q6, Q7, Q8: 2N7002; SOT-23
R1: 1k; R_1206_3216Metric
R2, R8: 33k; R_1206_3216Metric
R3, R4, R5, R6, R7, R12, R13: 10k; R_1206_3216Metric
R9: 330; R_1206_3216Metric
R10: 3.3k; R_1206_3216Metric
R11: 680k; R_1206_3216Metric
R14, R15: 22k; R_1206_3216Metric
R16: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R17: 0; R_1206_3216Metric
SW1, SW2, SW3, SW3#2, SW4, SW4#2: SW_Push; SW_SPST_TL3342
TP1, TP2, TP3, TP4, TP5, TP6: TestPoint; TestPoint_Pad_D1.5mm
U1: AP1117-33; SOT-223-3_TabPin2
U2: ESP-12F; ESP-12E

Connections:
GND: BT1.2, C1.2, C2.2, C3.1, C4.2, C5.2, J1.2, J2.2, Q2.2, Q3.2, Q4.2, Q5.2, Q6.2, Q7.2, Q8.2, R2.2, R5.1, R9.2, R12.2, R17.1, R17.2, SW1.1, SW2.1, SW3.1, SW3#2.1, SW4.1, SW4#2.1, U2.15
unnamed: BT1.1, D1.1, U1.3
unnamed: C1.1, U1.1
unnamed: C6.1, D2.2, Q4.3, Q7.1, R16.2
unnamed: C7.1, Q5.3, R11.2
unnamed: C7.2, Q4.1, R9.1
unnamed: J1.4, U2.22
unnamed: Q1.2, Q2.3
unnamed: Q1.3, Q3.1, R8.1
unnamed: Q7.3, Q8.1, R14.2
unnamed: R3.1, U2.3
VCC: C2.1, C3.2, D1.2, D2.1, J1.1, J2.1, R1.1, R2.1, R3.2, R4.1, R6.2, R7.2, R8.2, R10.1, R11.1, R13.1, R14.1, R15.2, R16.1, U1.2, U2.8
nrst: Q8.3, R1.2, R15.1, SW1.2, U2.1, U2.4
nxt: C4.1, J1.3, Q1.1, R6.1, SW3.2, SW3#2.2, U2.21
nxt+prv: C6.2, Q3.3, Q5.1, R10.2
prv: C5.1, Q2.1, R7.1, SW4.2, SW4#2.2, U2.17
spi-busy,flash: J2.8, R4.2, SW2.2, TP6.1, U2.18
spi-clk: J2.4, TP2.1, U2.5
spi-cs: J2.5, R5.2, TP3.1, U2.16
spi-dc: J2.6, TP4.1, U2.19
spi-mosi: J2.3, TP1.1, U2.7
spi-nrst: J2.7, Q6.3, R13.2
spi-rst: Q6.1, R12.1, TP5.1, U2.20

## Commit log

2022-05-18 updated hardware diagram and added woking epd4in2b_v2 driver
2022-05-18 removed build
2022-05-18 added gitignore
2022-05-18 finished the painter and added fonts
2022-05-24 added web skeleton and web db schema
2022-05-24 added classroom to web
2022-05-25 fixed classroom
2022-05-25 removed unnecesary file
2022-05-25 removed db
2022-05-27 added document
2022-05-27 added device
2022-05-28 finished first iteration of web frontend
2022-05-28 migrated each page warnings blocks to generic warnings block
2022-05-30 finished all frontend web but for add device
2022-05-30 updated dummy
2022-06-04 mayor hardware revision
2022-06-04 changed p-mosfet for n-mosfet in signal inversor
2022-06-06 mayor hardware change, fixed bad mosfet connection, increase c6 value to 37uF and decreased R1 to 1k and R10 to 3.3k, and tidy up the pcb desing so fast traces are length minimized
2022-06-08 finished :)
2022-07-06 fixed monostable and improved pcb layout
2022-07-13 changed nxt and prv port
2022-07-13 removed simplified version
2022-07-13 removed simplifiedd version
2022-07-13 redesing pcb and added isolation mosfets
2022-07-19 the hardware works
2022-07-20 decoupled esp to monostable via button trace
2022-08-01 finished hardware and software prototypes
2022-08-05 added documentation base
2022-08-05 updated gitignore
2022-08-17 finished web by adding error pages and limited access to non administrator users
2022-08-17 removed documentation
2022-08-19 added teacher selection in classrooms
2022-09-11 final update
